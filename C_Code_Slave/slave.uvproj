# Keil uVision project slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC82G516 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x3FF) CLOCK(24000000)
  output: slave +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../: Delay_1T.A51 STARTUP.A51 ascii.c
    ./: main.c modbus.c slave.c
